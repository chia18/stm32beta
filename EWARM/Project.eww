<?xml version="1.0" encoding="UTF-8"?>
<workspace>
  <project>
    <path>$WS_DIR$\Lightbar_FEM_RH1.ewp</path>
  </project>
  <batchBuild />
</workspace>
